# Keil uVision project CX26xx-Prj1.uvprojx, settings and files
target CX26xx-Prj1 (5060960::V5.06 update 7 (build 960)::.\complier_v5)
  device: -AT32F421C8T7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.8
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: CX26xx-Prj1 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: AT32F421C8T7,USE_STDPERIPH_DRIVER,AT_START_F421_V1_0
  c include: ..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\..\Driver;..\..\..\mylib;..\..\..\TaskList;..\..\..\Protocol
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group USER
    ../: main.c at32f4xx_it.c
  group CMSIS
    ../: system_at32f4xx.c
    ../../../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f421c8t7.s
  group AT32Periph
    ../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_acc.c at32f4xx_adc.c at32f4xx_can.c at32f4xx_crc.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_i2c.c at32f4xx_iwdg.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_spi.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_wwdg.c at32f4xx_ertc.c at32f4xx_comp.c at32f4xx_syscfg.c at32f4xx_gpio_ex.c misc.c
  group README
    ../: readme.txt
  group Driver
    ../../../Driver/: crc.c exAdc.c flash.c IoPort.c rtc.c Time.c uart.c spi.c
  group mylib
    ../../../mylib/: myString.c TimeStamp.c
  group Protocol
    ../../../Protocol/: RSms128.c yotliveMs128.c
  group TaskList
    ../../../TaskList/: debugCli.c sampleTask.c systemInit.c
